# IAR project USBH_MSD.ewp, settings and files
configuration Flash Debug K60 (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: IAR; FREESCALE_MMCAU
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\mfs; ..\..\flash_driver; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\decrypt; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\host_common; ..\..\..\..\source\classes; ..\..\..\..\source\classes\cdc; ..\..\..\..\source\classes\hid; ..\..\..\..\source\classes\hub; ..\..\..\..\source\classes\msd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSD.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MK60N512CMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../: Loader.c main.c
    ../../../common/kinetis/: PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../common/: poll.c poll.h
  group app/flash_driver
    ../../flash_driver/: flash_FTFL.c
  group app/mfs
    ../../mfs/: ccsbcs.c diskio.c ff.c
  group bsp/P2
    ../../../../source/bsp/P2/: P2.c
  group class
    ../../../../source/classes/common/: usb_classes.c
  group class/hub
    ../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group class/msd
    ../../../../source/classes/msd/: usb_host_msd_bo.c usb_host_msd_queue.c usb_host_msd_ufi.c
  group decrypt
    ../../../../source/decrypt/: aes.c mmcau_lib.a
    ../../../../../../../../../bootloader_enc_working/USB_MSD_Host_aes_v10/bootloader_code/Source/Host/source/decrypt/: crypto_common.h
  group driver
    ../../../../source/driver/kinetis/: khci_kinetis.c
    ../../../../source/driver/: usbevent.c usbmsgq.c usbsem.c
  group host_common
    ../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group prm
    config/: MK60N512CMD100_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
